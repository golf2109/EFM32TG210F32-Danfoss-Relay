# Keil uVision project TG210.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: EFM32TG210F32 Silicon Labs
  pack: Keil.EFM32TGxxx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TG210
  AfterMake: C:\keilkill.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EFM32TG210F32
  c include: .\Init;..\EFM32TG210F32_MBUS
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./: main.c danfoss.c
  group Init
    ./Init/: InitDevice.c InitDevice.h
software components: CMSIS:CORE 4.3.0, Device:Startup 4.2.1, Device:emlib:CMU 4.2.1, Device:emlib:DMA 4.2.1, Device:emlib:EMU 4.2.1, Device:emlib:Framework 4.2.1, Device:emlib:GPIO 4.2.1, Device:emlib:LEUART 4.2.1, Device:emlib:SYSTEM 4.2.1, Device:emlib:TIMER 4.2.1, Device:emlib:USART 4.2.1
